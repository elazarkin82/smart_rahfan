SRCREV:radxa-zero-3 = "2e2ae1fb69a25217640bfe2fb9abaf9f4fbacead"
SRCREV:radxa-zero-3:rk-u-boot-env = "2e2ae1fb69a25217640bfe2fb9abaf9f4fbacead"

SRCREV:radxa-zero-3e = "2e2ae1fb69a25217640bfe2fb9abaf9f4fbacead"
SRCREV:radxa-zero-3e:rk-u-boot-env = "2e2ae1fb69a25217640bfe2fb9abaf9f4fbacead"
